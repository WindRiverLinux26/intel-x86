require linux-yocto-intel-x86.inc

KBRANCH:intel-x86  = "v6.18/standard/preempt-rt/x86"

LINUX_VERSION:intel-x86 ?= "6.18.x"
